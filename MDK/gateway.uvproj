# Keil uVision project gateway.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F205RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: gateway
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\LIB\STM32F2xx_StdPeriph_Driver\inc;..\LIB\CMSIS\Include;..\USER;..\LIB\CMSIS\Device\ST\STM32F2xx\Include;..\CANopen;..\CANopen\include;..\CANopen\include\stm32
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group USER
    ../USER/: main.c stm32f2xx_it.c system_stm32f2xx.c
  group CMSIS
    ../LIB/CMSIS/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
  group LIB
    ../LIB/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group StartUp
    ../LIB/CMSIS/Device/ST/STM32F2xx/Source/Templates/arm/: startup_stm32f2xx.s
  group MODBUS
    ../USER/: MB_PFunction.c MB_RTU.c MBCommon.c MBSlave.c MBSlave.h MODBUS.h modbus_config.h
  group CANopen_Driver
    ../CANopen/driver/: can_stm32.c timer_stm32.c
  group CANopen_SRC
    ../CANopen/src/: dcf.c emcy.c lifegrd.c lss.c nmtMaster.c nmtSlave.c objacces.c pdo.c sdo.c states.c sync.c timer.c
  group CANopen_OBJDict
    ../CANopen/: ObjDict1.c ObjDict1.h ObjDict2.c ObjDict2.h
